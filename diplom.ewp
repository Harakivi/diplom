# IAR project diplom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; CMSIS; mylibs\hdr; mylibs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: diplom.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp main.h
  group CMSIS
    CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group mylibs/hdr
    mylibs/hdr/: delay.h DS18b20lib.h Init.h keyboard.h lcd.h lcd5110.h PID_v1.h stm32f1xx_it.h
  group mylibs/src
    mylibs/src/: delay.c DS18b20lib.c Init.c keyboard.c lcd.c lcd5110.c PID_v1.cpp stm32f1xx_it.c
